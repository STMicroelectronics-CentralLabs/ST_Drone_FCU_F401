<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ToyDrone.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Toydrone</name>
      <member>
        <project>ToyDrone</project>
        <configuration>ToyDrone Configuration</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


