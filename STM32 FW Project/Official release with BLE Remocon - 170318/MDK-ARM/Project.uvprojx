# Keil uVision project Project.uvprojx, settings and files
target ToyDrone Configuration (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401VCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ToyDrone Configuration
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC,DEBUG
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/BSP/Board;../Drivers/BSP/Components/lsm6ds33;../Drivers/BSP/Components/lis3mdl;../Drivers/BSP/Components/lps25hb;../Drivers/BSP/Components/Common;../Drivers/BSP/Components/lsm6dsl;../Drivers/BSP/Components/lps22hb;../Drivers/BSP/Components/lsm303agr;../Drivers/BSP/STEVAL_FCU001_V1;../Drivers/BSP/Components/lis2mdl;../Drivers/BlueNRG;../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/includes;../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/includes;../Drivers/BSP/Components/spbtlerf
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_adc.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_ll_usb.c stm32f4xx_hal_pcd.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_uart.c
  group Middlewares/STM32_BlueNRG/HCI/Controller
    ../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_utils.c bluenrg_l2cap_aci.c bluenrg_gap_aci.c bluenrg_updater_aci.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_BlueNRG/Interface
    ../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Middlewares/STM32_BlueNRG/Utils
    ../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: ble_list.c gp_timer.c osal.c
  group Application/User
    ../Src/: usbd_conf.c usbd_desc.c flight_control.c stm32f4xx_hal_msp.c timer.c sensor_service.c console.c rc.c ahrs.c main.c sensor_data.c basic_math.c stm32f4xx_it.c quaternion.c debug.c usb_device.c motor.c usbd_cdc_if.c
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Middlewares/STM32_BlueNRG/HCI
    ../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
  group Drivers/Board
    ../Drivers/BSP/STEVAL_FCU001_V1/: steval_fcu001_v1.c steval_fcu001_v1_accelero.c steval_fcu001_v1_gyro.c steval_fcu001_v1_magneto.c steval_fcu001_v1_pressure.c steval_fcu001_v1_temperature.c
  group Drivers/Components
    ../Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver_HL.c LSM6DSL_ACC_GYRO_driver.c
    ../Drivers/BSP/Components/lis2mdl/: LIS2MDL_MAG_driver_HL.c LIS2MDL_MAG_driver.c
    ../Drivers/BSP/Components/lsm303agr/: LSM303AGR_MAG_driver.c LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver_HL.c
    ../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver_HL.c LPS22HB_Driver.c
    ../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver_HL.c LIS3MDL_MAG_driver.c
    ../Drivers/BSP/Components/spbtlerf/: SPBTLE_RF.c
software components: CMSIS:CORE 4.3.0
